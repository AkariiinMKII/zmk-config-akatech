## boards/shields/minimi/Kconfig.defconfig
```kconfig
if SHIELD_MINIMI

config ZMK_KEYBOARD_NAME
    default "MiniMi"

endif # SHIELD_MINIMI
```
